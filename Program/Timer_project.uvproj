# Keil uVision project Timer_project.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: Timer_project +hex
  c flags: Optimize=8 SizeSpeed=1
  group MAIN
    ./USER/: main.c LED_Shift.c PCF8563.C Setting.c AUTO_Brightness.C DHT11.C nong.c
  group SYSTEM
    ./USER/: INTERRPUT.C LED_Scan.c delay.c USART1.C ADC.c
